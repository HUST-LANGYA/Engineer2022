# Keil uVision project EngineerUpper.uvprojx, settings and files
target EngineerUpper (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EngineerUpper
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: ..\User;..\Library\inc;..\Mylib;..\Algorithm;..\Task;..\FreeRTOS\include;..\FreeRTOS\port\MemMang;..\FreeRTOS\port\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c system_stm32f10x.c stm32f10x_it.c startup_stm32f10x_cl.s
  group Library
    ../Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Mylib
    ../Mylib/: can1.c delay.c iwdg.c Nvic.c tim.c tim2.c Usart3.c ZeroCheck.c can2.c
  group Algorithm
    ../Algorithm/: ModbusCRC16.c pid.c
  group Task
    ../Task/: AutoexecTask.c ClampAngleTask.c ForwardTask.c LiftTask.c MotorTask.c RotateTask.c StartTask.c StateTask.c
  group FreeRTOS/Src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM3/: port.c
